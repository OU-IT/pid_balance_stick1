# Keil uVision project T.uvprojx, settings and files
target mpu6050_test (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: T
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F401xx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries;.\Libraries\inc;.\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Mylib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_conf.h
  group Startup
    ./Libraries/: startup_stm32f40_41xxx.s
  group CMSIS
    ./Libraries/: system_stm32f4xx.c
  group Std_lib
    ./Libraries/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c misc.c
    ../T/Libraries/src/: stm32f4xx_i2c.c
  group Mylib
    ./Mylib/: i2c.c i2c.h mpu6050.c mpu6050.h delay.c delay.h uart.c uart.h kalman.c kalman.h motor.c motor.h pid.c pid.h
